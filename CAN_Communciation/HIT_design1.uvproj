# Keil uVision project HIT_design1.uvproj, settings and files
target Target 1 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HIT_design1 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\lib\inc;.\mylib\inc;.\mylib\inc\TFT;.\mylib\inc;.\mylib\inc\TIME1_PWM;.\mylib\inc\USART;.\mylib\inc\ENCODE;.\mylib\inc\PID;.\mylib;.\mylib\inc\ENCODE;.\mylib\inc\ADC;.\mylib\inc\CAN
  asm include: .\lib\src;.\lib\inc;.\mylib\inc;.\mylib\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./User/: main.c stm32f10x_it.c
    ./lib/inc/: stm32f10x_lib.h
    ./mylib/: config.h
  group lib_src
    ./lib/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_tim1.c stm32f10x_usart.c stm32f10x_wwdg.c
  group lib_inc
    ./lib/inc/: cortexm3_macro.h ip_arp_udp_tcp.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_conf.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_it.h stm32f10x_iwdg.h stm32f10x_lib.h stm32f10x_map.h stm32f10x_nvic.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_systick.h stm32f10x_tim.h stm32f10x_tim1.h stm32f10x_type.h stm32f10x_usart.h stm32f10x_wwdg.h TYC_GPIO_Init.h UET_GPIO.h
  group mylib_src
    ./mylib/src/TFT/: delay.c
    ./mylib/src/USART/: usart.c
    ./mylib/src/ENCODE/: encode.c
    ./mylib/src/PID/: pid.c
    ./mylib/src/: reset.c
    ./mylib/src/ADC/: adc.c kalman.c
    ./mylib/: init.c
    ./mylib/src/TIME1_PWM/: spwm.c
    ./mylib/src/CAN/: can.c
  group mylib_inc
    ./mylib/inc/TFT/: delay.h
    ./mylib/inc/USART/: usart.h
    ./mylib/inc/ENCODE/: encode.h
    ./mylib/inc/PID/: pid.h
    ./mylib/inc/: reset.h
    ./mylib/inc/ADC/: adc.h kalman.h
    ./mylib/inc/TIME1_PWM/: spwm.h
    ./mylib/inc/CAN/: can.h
  group start
    ./start/: cortexm3_macro.s stm32f10x_vector.s
